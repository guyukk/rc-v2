# Keil uVision project smartcat-stm32f4.uvprojx, settings and files
target smartcat-stm32f4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: smartcat-stm32f4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../../Core/Inc;../../Drivers/STM32F4xx_HAL_Driver/Inc;../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../Drivers/CMSIS/Include;./System;..\..\BSP\H
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../../Core/Src/: usart.c turn.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c sg90.c sg90_test.c Remote_OLED_display.c pid.c oled.c ms200.c motor.c main.c linearRegression.c gpio.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
